## sx1276/Kconfig
```kconfig
config UPM_sx1276
    bool "sx1276"
    select MRAA
    select NEWLIB_LIBC
    depends on UPM
    default n
    help
        LORA Module
```
